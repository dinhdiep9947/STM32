# Keil uVision project UART_ADC.uvprojx, settings and files
target UART_ADC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: UART_ADC
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --C99
  c include: ../Inc;                              ../Drivers/STM32F4xx_HAL_Driver/Inc;                              ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                              ../Drivers/CMSIS/Include;                              ../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc.c
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
software components: CMSIS:CORE 4.1.0
